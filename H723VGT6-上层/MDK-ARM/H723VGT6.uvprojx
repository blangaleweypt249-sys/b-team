# Keil uVision project H723VGT6.uvprojx, settings and files
target H723VGT6 (6240000::V6.24::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H723VGT6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Drivers/CMSIS/RTOS2/Include; ../Core/Inc; ../User/BSP/Can; ../User/BSP/Communication; ../User/Driver/Can; ../User/Driver/Motor; ../User/Driver/Motor/M2006; ../User/Driver/Motor/M3508; ../User/Driver/Motor/DM J4310; ../User/Driver/PcLink; ../User/Driver/Flash; ../User/Algorithm/Pid; ../User/Algorithm/MotorOnlineTune; ../User/App/Arm; ../User/App/Conveyor; ../User/App/Gripper; ../User/Application/Communication; ../User/Application/Robot; ../User/Application/Task; ../User/Config; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c usart.c spi.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group User/BSP
    ../User/BSP/Can/: bsp_can.c
    ../User/BSP/Communication/: comm_runtime.c
  group User/Driver/Motor/Core
    ../User/Driver/Motor/: motor_manager.c upper_motor_port.c
  group User/Driver/Motor/DJI
    ../User/Driver/Motor/DJI/: dji_group.c
  group User/Driver/Motor/LK MG5010E-i36
    ../User/Driver/Motor/LK MG5010E-i36/: mg5010.c
  group User/Driver/Motor/DM J4310
    ../User/Driver/Motor/DM J4310/: j4310.c
  group User/Driver/Motor/M3508
    ../User/Driver/Motor/M3508/: m3508.c
  group User/Driver/Motor/M2006
    ../User/Driver/Motor/M2006/: m2006.c
  group User/Driver/PcLink
    ../User/Driver/PcLink/: pc_protocol.c
  group User/Algorithm
    ../User/Algorithm/Pid/: pid.c
    ../User/Algorithm/MotorOnlineTune/: motor_online_tune.c
  group User/App
    ../User/App/Arm/: arm.c
    ../User/App/Conveyor/: conveyor.c
    ../User/App/Gripper/: gripper.c
  group User/Application
    ../User/Application/Communication/: upper_pc_link.c upper_remote_link.c
    ../User/Application/Robot/: upper_robot.c j4310_auto_return.c j4310_position_control.c
    ../User/Application/Task/: upper_entry.c
  group User/Driver/Flash
    ../User/Driver/Flash/: W25Qxx.c
  group User/Config
    ../User/Config/: upper_config.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/: port.c
software components: CMSIS:CORE 4.3.0
